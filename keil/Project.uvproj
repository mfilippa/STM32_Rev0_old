# Keil uVision project Project.uvproj, settings and files
target STM32F103_HD (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_HD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\source;..\source\stlib\inc;..\source\support;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../source/app/: main.c sch.c fault.c acdr.c bldc.c ctrl.c dpwm.c lib.c comm.c linear.c
  group hal
    ../source/hal/: io.c irq.c pwm.c fb.c spd.c sys.c serial.c
  group hw
    ../source/hw/: adc.c gpio.c tmr.c uart.c enc.c hwcfg.c
  group support
    ../source/support/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group stlib
    ../source/stlib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
